# Keil uVision project KeyPad.uvprojx, settings and files
target DEBUG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KeyPad_Debug +hex
  BeforeMake: version.exe debug $P
  AfterMake: backup_hex.bat !H $P
  AfterMake: ..\hex\version_crc.bat %H
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: AFIO_MAPR_SWJ_CFG_VAL FW_DEBUG
  c include: c:\Keil_v5\ARM\Packs\ARM\CMSIS-FreeRTOS\10.5.1\CMSIS\RTOS2\FreeRTOS\Include1\;c:\Keil_v5\ARM\Packs\Keil\STM32F1xx_DFP\2.4.0\RTE_Driver\;.\Source\
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: readme.txt
    ./Source/: main.c uart.c command.c led.c parse.c ports.c button.c data.c message.c key.c version.c config.c crc16.c
target RELEASE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: KeyPad_Release +hex
  BeforeMake: version.exe release $P
  AfterMake: backup_hex.bat !H $P
  AfterMake: ..\hex\version_crc.bat %H
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: AFIO_MAPR_SWJ_CFG_VAL FW_RELEASE
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, CMSIS Driver:USART 2.3, Device:DMA 1.3, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:IWDG 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0
